inherit setuptools
require ../layers/meta-openembedded/meta-python/recipes-devtools/python/python-spidev.inc
