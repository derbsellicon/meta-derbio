FILESEXTRAPATHS_prepend := "${THISDIR}/hostapd"

SRC_URI += "file://hostapd.conf" 
