FILESEXTRAPATHS_prepend := "${THISDIR}/opkg"

SRC_URI += "file://opkg.conf" 
