FILESEXTRAPATHS_prepend := "${THISDIR}/weston-init:"

SRC_URI += "file://weston.ini" 

