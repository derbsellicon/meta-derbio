FILESEXTRAPATHS_prepend := "${THISDIR}/alsa-equal:"

SRC_URI_append = "file://0004-fix-path-to-caps-on-arm64.patch" 

